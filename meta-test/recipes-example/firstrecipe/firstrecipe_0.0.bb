PN = 'firstrecipe'
PV = '1'  
DESCRIPTION = "Our first recipe for bitbake hello world"
